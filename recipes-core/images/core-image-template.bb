#
#   Copyright (C) 2017 Pelagicore AB
#   SPDX-License-Identifier: MIT
#

DESCRIPTION = "\
    A template image inheriting the PELUX image. This image recipe  \ 
    should be used as an example once the project decides to create \
    its own project specific image based on PELUX.                  \
"

require recipes-core/images/core-image-pelux.bb

